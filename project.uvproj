# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\components\CMSIS\Include;HZ_ASCII_Lib;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\components\net\freemodbus-v1.6.0\modbus\include;..\..\components\net\freemodbus-v1.6.0\modbus\rtu;..\..\components\net\freemodbus-v1.6.0\port;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include\netif
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c bsp_rtc.c stm32f10x_it.c adc.c rs485.c led.c key.c spi_flash.c usart.c dm9000a.c spfd5420a.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group HZ_ASCII_Lib
    HZ_ASCII_Lib/: AsciiLib.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../components/init/: components.c
  group FreeModbus
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfuncdiag.c mbutils.c mbfuncother.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbcrc.c mbrtu.c
    ../../components/net/freemodbus-v1.6.0/port/: port.c user_mb_app.c portevent.c portserial.c porttimer.c
    ../../components/net/freemodbus-v1.6.0/modbus/: mb.c
  group LwIP
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
